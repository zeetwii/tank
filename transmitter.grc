options:
  parameters:
    author: ZeeTwii
    copyright: '2023'
    description: A RF controller for a toy tank
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: Tank Controller
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 40.68e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: toy_samp_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {}
- name: toyTank_spoofer_0
  id: toyTank_spoofer
  parameters:
    overSample: int(samp_rate / toy_samp_rate)
    portNum: '7331'
  states: {}

connections:
- [blocks_float_to_complex_0, '0', qtgui_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', soapy_hackrf_sink_0, '0']
- [toyTank_spoofer_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
